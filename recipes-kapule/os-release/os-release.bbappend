KAPULE_IMAGE_TYPE ?= "Kapule-linux"

DISTRO_CODENAME = "${KAPULE_IMAGE_TYPE}"
BUILD_ID ?= "${DATETIME}"
